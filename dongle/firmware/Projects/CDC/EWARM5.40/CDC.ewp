# IAR project CDC.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xx4 ST STM32F10xx4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\; ..\..\; ..\..\..\; ..\..\..\Tools\fifo\; ..\..\..\HW\Port\IAR\; ..\..\..\HW\Port\IAR\Delay\; ..\..\..\HW\; ..\..\..\HW\lib\CMSIS\Core\CM3\; ..\..\..\HW\lib\inc\; ..\..\..\HW\VCOM\; ..\..\..\HW\Mass\; ..\..\..\Interfaces\PowerExt\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: CDC_IAR.hex
  ILINK.IlinkOutputFile: CDC.out
  ILINK.IlinkIcfFile: CDC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCOptStrategy: 1
  group (top)
    ../: app_cfg.h
    ../../../: main.c
  group HW
    ../../../HW/: HW.c stm32f10x_it.c
  group HW/Lib
    ../../../HW/lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group HW/Lib/CMSIS
    ../../../HW/lib/CMSIS/Core/CM3/: core_cm3.c
  group HW/Lib/CMSIS/startup
    ../../../HW/lib/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s
  group HW/Port/Delay
    ../../../HW/Port/IAR/Delay/: delay.c
  group HW/USB/Mass
    ../../../HW/Mass/: mass_mal.c memory.c scsi_data.c usb_bot.c usb_scsi.c
  group HW/USB/ST_VCOM
    ../../../HW/VCOM/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group hw_cfg
    ../../: hw_cfg_MiniRC2.h hw_cfg_MiniRC3.h hw_cfg_MiniRC4.h hw_cfg_NanoRC1.h hw_cfg_ProRC1.h
  group Interfaces/PowerExt
    ../../../Interfaces/PowerExt/: PowerExt.c
  group Tools/fifo
    ../../../Tools/fifo/: fifo.c
