# IAR project USBBlaster.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xx8 ST STM32F10xx8
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\; ..\..\; ..\..\..\; ..\..\..\HW\Port\IAR\; ..\..\..\HW\; ..\..\..\HW\STM32F10x_Lib\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\HW\STM32F10x_Lib\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\HW\STM32F10x_Lib\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\HW\STM32F10x_Lib\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\HW\Mass\; ..\..\..\USBBlaster\; ..\..\..\USBBlaster\USBBlaster; ..\..\..\USBBlaster\USB; ..\..\..\Interfaces\JTAG\; ..\..\..\Interfaces\SWD\; ..\..\..\Interfaces\SWIM\; ..\..\..\Interfaces\SPI\; ..\..\..\Interfaces\PowerExt\; ..\..\..\Interfaces\IIC\; ..\..\..\Interfaces\C2\; ..\..\..\Interfaces\ISSP\; ..\..\..\Interfaces\LPC_ICP\; ..\..\..\Interfaces\MSP430_JTAG\; ..\..\..\Interfaces\BDM\; ..\..\..\Interfaces\USBBlaster_JTAG&AS\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: USBBlaster.hex
  ILINK.IlinkOutputFile: USBBlaster.out
  ILINK.IlinkIcfFile: USBBlaster.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; NDEBUG
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: USBBlaster.srec
  group (top)
    ../: app_cfg.h
    ../../../USBBlaster/: CommandProcessor.c
    ../../../: main.c
  group HW
    ../../../HW/: HW.c stm32f10x_it.c
  group HW/STM32F10x_Lib/Libraries/CMSIS
    ../../../HW/STM32F10x_Lib/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../HW/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group HW/STM32F10x_Lib/Libraries/STM32_USB-FS-Device_Driver
    ../../../HW/STM32F10x_Lib/Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group HW/STM32F10x_Lib/Libraries/STM32F10x_StdPeriph_Driver
    ../../../HW/STM32F10x_Lib/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group hw_cfg
    ../../: hw_cfg_MiniRC2.h hw_cfg_MiniRC3.h hw_cfg_MiniRC4.h hw_cfg_MiniRelease1.h hw_cfg_NanoRelease1.h hw_cfg_ProRC1.h hw_cfg_STBee_Mini.h
  group Interfaces/PowerExt
    ../../../Interfaces/PowerExt/: PowerExt.c
  group Interfaces/USBBlaster_JTAG&AS
    ../../../Interfaces/USBBlaster_JTAG&AS/: USBBlaster_JTAG&AS.c
  group USBBlaster/USB
    ../../../USBBlaster/USB/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
