# IAR project STK500v2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xx8 ST STM32F10xx8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\; ..\..\; ..\..\..\; ..\..\..\HW\Port\IAR\; ..\..\..\HW\; ..\..\..\HW\STM32F10x_Lib\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\HW\STM32F10x_Lib\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\HW\STM32F10x_Lib\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\HW\STM32F10x_Lib\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Interfaces\; ..\..\..\Interfaces\GPIO\; ..\..\..\Interfaces\PowerExt\; ..\..\..\Interfaces\JTAG\; ..\..\..\STK500v2; ..\..\..\STK500v2\USB
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STK500v2_IAR.hex
  ILINK.IlinkOutputFile: STK500v2.out
  ILINK.IlinkIcfFile: STK500v2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\; ..\..\; ..\..\..\; ..\..\..\HW\Port\IAR\; ..\..\..\HW\; ..\..\..\HW\STM32F10x_Lib\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\HW\STM32F10x_Lib\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\HW\STM32F10x_Lib\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\HW\STM32F10x_Lib\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Interfaces\; ..\..\..\Interfaces\GPIO\; ..\..\..\Interfaces\JTAG\; ..\..\..\Interfaces\SPI\; ..\..\..\Interfaces\PowerExt\; ..\..\..\STK500v2; ..\..\..\STK500v2\USB
  ICCARM.CCOptStrategy: 0
  group (top)
    ../: app_cfg.h
    ../../../: main.c
  group HW
    ../../../HW/: HW.c stm32f10x_it.c
  group HW/STM32F10x_Lib/Libraries/CMSIS/CM3/CoreSupport
    ../../../HW/STM32F10x_Lib/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group HW/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x
    ../../../HW/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group HW/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup
    ../../../HW/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s
  group HW/STM32F10x_Lib/Libraries/STM32_USB-FS-Device_Driver
    ../../../HW/STM32F10x_Lib/Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group HW/STM32F10x_Lib/Libraries/STM32F10x_StdPeriph_Driver
    ../../../HW/STM32F10x_Lib/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group hw_cfg
    ../../: hw_cfg_MiniRC2.h hw_cfg_MiniRC3.h hw_cfg_MiniRC4.h hw_cfg_MiniRelease1.h hw_cfg_NanoRelease1.h hw_cfg_ProRC1.h hw_cfg_STBee_Mini.h
  group Interfaces
    ../../../Interfaces/: interfaces.c
  group Interfaces/GPIO
    ../../../Interfaces/GPIO/: GPIO.c
  group Interfaces/JTAG
    ../../../Interfaces/JTAG/: JTAG_TAP.c
  group Interfaces/PowerExt
    ../../../Interfaces/PowerExt/: PowerExt.c
  group Interfaces/SPI
    ../../../Interfaces/SPI/: SPI.c
  group STK500v2
    ../../../STK500v2/: CommandProcessor.c STK500.c STK500_ISP.c STK500v2.c STK500v2_AVR32_JTAG.c STK500v2_MEGA_JTAG.c STK_Param.c
  group STK500v2/Target/AVR32_JTAG
    ../../../STK500v2/Target/AVR32_JTAG/: AVR32_JTAG.c
  group STK500v2/Target/AVR_ISP
    ../../../STK500v2/Target/AVR_ISP/: AVR_ISP.c
  group STK500v2/Target/MEGA_JTAG
    ../../../STK500v2/Target/MEGA_JTAG/: MEGA_JTAG_PRG.c
  group STK500v2/USB
    ../../../STK500v2/USB/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
