# IAR project Versaloon.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_XL; _HARDWARE_VER=0x15; __TARGET_CHIP__=stm32; FLASH_LOAD_OFFSET=0x8000; CORE_DEBUG=STM32_DBG_SWD
  ICCARM.CCIncludePath2: ; ..\; ..\vsf_cfg; ..\..\; ..\..\..\; ..\..\..\Interfaces\; ..\..\..\Interfaces\APP\; ..\..\..\USB_TO_XXX\; ..\..\..\versaloon_usb\; ..\..\..\stlink\; ..\..\..\..\..\vsf\; ..\..\..\..\..\vsf\compiler\IAR\; ..\..\..\..\..\vsf\tool\list; ..\..\..\..\..\vsf\interfaces\; ..\..\..\..\..\vsf\interfaces\cpu\stm32\; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\Port\IAR\; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\STM32F10x_Lib\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\STM32F10x_Lib\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\STM32F10x_Lib\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\STM32F10x_Lib\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\..\src\scripts; ..\..\..\..\..\src\target; ..\..\..\..\..\src\tools\memlist; ..\..\..\..\..\src\tools\strparser; ..\..\..\app_script; ..\..\..\vsprog; ..\..\..\vsprog\tools\pgbar; ..\..\..\vsprog\driver\comport; ..\..\..\vsprog\target; ..\..\..\..\..\src\target\core\arm_adi; ..\..\..\..\..\src\target\comisp; ..\..\..\..\..\src\target\cortex-m; ..\..\..\..\..\src\target\at91sam3; ..\..\..\..\..\src\target\lm3s; ..\..\..\..\..\src\target\lpc1000; ..\..\..\..\..\src\target\stm32f1; ..\..\..\..\..\src\target\stm32f2; ..\..\..\..\..\src\target\stm32l1; ..\..\..\..\..\src\target\nuc100; ..\..\..\..\..\src\target\kinetis
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Versaloon_IAR.hex
  ILINK.IlinkOutputFile: Versaloon.out
  ILINK.IlinkIcfFile: ..\..\Versaloon.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_XL; _HARDWARE_VER=0x15; __TARGET_CHIP__=stm32; FLASH_LOAD_OFFSET=0x8000; CORE_DEBUG=STM32_DBG_NONE
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Versaloon.bin
  group (top)
    ../: app_cfg.h port.c
    ../../../: app_io.c main.c
  group hw_cfg
    ../../: hw_cfg_MiniRelease1.h hw_cfg_NanoRelease1.h hw_cfg_ProRelease1.h hw_cfg_ProRelease3.h hw_cfg_st_link.h hw_cfg_STBee_Mini.h
  group Interfaces
    ../../../Interfaces/: app_interfaces.c
  group Interfaces/APP/ADC
    ../../../Interfaces/APP/ADC/: ADC.c
  group Interfaces/APP/BDM
    ../../../Interfaces/APP/BDM/: BDM.c
  group Interfaces/APP/C2
    ../../../Interfaces/APP/C2/: C2.c
  group Interfaces/APP/CLKO
    ../../../Interfaces/APP/CLKO/: CLKO.c
  group Interfaces/APP/DUSI
    ../../../Interfaces/APP/DUSI/: DUSI.c
  group Interfaces/APP/EBI
    ../../../Interfaces/APP/EBI/: EBI.c
  group Interfaces/APP/GPIO
    ../../../Interfaces/APP/GPIO/: GPIO.c
  group Interfaces/APP/IIC
    ../../../Interfaces/APP/IIC/: IIC.c
  group Interfaces/APP/ISSP
    ../../../Interfaces/APP/ISSP/: ISSP.c
  group Interfaces/APP/JTAG
    ../../../Interfaces/APP/JTAG/: JTAG_TAP.c
  group Interfaces/APP/LPC_ICP
    ../../../Interfaces/APP/LPC_ICP/: LPC_ICP.c
  group Interfaces/APP/MicroWire
    ../../../Interfaces/APP/MicroWire/: MicroWire.c
  group Interfaces/APP/MSP430_JTAG
    ../../../Interfaces/APP/MSP430_JTAG/: MSP430_JTAG.c
  group Interfaces/APP/PowerExt
    ../../../Interfaces/APP/PowerExt/: PowerExt.c
  group Interfaces/APP/PWM
    ../../../Interfaces/APP/PWM/: PWM.c
  group Interfaces/APP/SDIO
    ../../../Interfaces/APP/SDIO/: SDIO.c
  group Interfaces/APP/SPI
    ../../../Interfaces/APP/SPI/: SPI.c
  group Interfaces/APP/SWD
    ../../../Interfaces/APP/SWD/: SWD.c
  group Interfaces/APP/SWIM
    ../../../Interfaces/APP/SWIM/: SWIM.c
  group Interfaces/APP/USART
    ../../../Interfaces/APP/USART/: USART.c
  group scripts
    ../../../../../src/scripts/: interfaces_script.c scripts.c
  group scripts/app_script
    ../../../app_script/: app_script.c
  group stlink
    ../../../stlink/: stlink.c
  group usb_protocol
    ../../../: usb_protocol_CDCACM.c usb_protocol_MSC.c usb_protocol_stlink.c usb_protocol_Versaloon.c usb_protocol_VersaloonSuper.c
  group USB_TO_XXX
    ../../../USB_TO_XXX/: CommandProcessor.c USB_TO_ADC.c USB_TO_BDM.C USB_TO_C2.c USB_TO_CLKO.c USB_TO_DAC.c USB_TO_DUSI.c USB_TO_EBI.c USB_TO_GPIO.c USB_TO_IIC.c USB_TO_ISSP.c USB_TO_JTAG_HL.c USB_TO_JTAG_LL.c USB_TO_JTAG_RAW.c USB_TO_LPCICP.c USB_TO_MICROWIRE.c USB_TO_MSP430_JTAG.c USB_TO_POWER.c USB_TO_PWM.c USB_TO_SPI.c USB_TO_SWD.c USB_TO_SWIM.c USB_TO_USART.c USB_TO_XXX.c
  group versaloon_usb
    ../../../versaloon_usb/: vsfusbd_Versaloon.c
  group vsf/dal
    ../../../../../vsf/dal/: dal.c
  group vsf/dal/cfi
    ../../../../../vsf/dal/cfi/: cfi_drv.c
  group vsf/dal/df25xx
    ../../../../../vsf/dal/df25xx/: df25xx_drv.c
  group vsf/dal/df45xx
    ../../../../../vsf/dal/df45xx/: df45xx_drv.c
  group vsf/dal/ee24cxx
    ../../../../../vsf/dal/ee24cxx/: ee24cxx_drv.c
  group vsf/dal/ee93cx6
    ../../../../../vsf/dal/ee93cx6/: ee93cx6_drv.c
  group vsf/dal/mal
    ../../../../../vsf/dal/mal/: mal.c
  group vsf/dal/mic2826
    ../../../../../vsf/dal/mic2826/: mic2826_drv.c
  group vsf/dal/nand
    ../../../../../vsf/dal/nand/: nand_drv.c
  group vsf/dal/nrf24l01
    ../../../../../vsf/dal/nrf24l01/: nrf24l01_drv.c
  group vsf/dal/s6b0724
    ../../../../../vsf/dal/s6b0724/: s6b0724_drv.c
  group vsf/dal/sd
    ../../../../../vsf/dal/sd/: sd_common.c sd_sdio_drv.c sd_spi_drv.c
  group vsf/dal/sst32hfxx
    ../../../../../vsf/dal/sst32hfxx/: sst32hfxx_drv.c
  group vsf/dal/stream
    ../../../../../vsf/dal/stream/: stream.c
  group vsf/dal/usart_stream
    ../../../../../vsf/dal/usart_stream/: usart_stream.c
  group vsf/interfaces
    ../../../../../vsf/interfaces/: interfaces.c
  group vsf/interfaces/cpu/stm32
    ../../../../../vsf/interfaces/cpu/stm32/: core.c
  group vsf/interfaces/cpu/stm32/adc
    ../../../../../vsf/interfaces/cpu/stm32/adc/: STM32_ADC.c
  group vsf/interfaces/cpu/stm32/clko
    ../../../../../vsf/interfaces/cpu/stm32/clko/: STM32_CLKO.c
  group vsf/interfaces/cpu/stm32/ebi
    ../../../../../vsf/interfaces/cpu/stm32/ebi/: STM32_EBI.c
  group vsf/interfaces/cpu/stm32/eint
    ../../../../../vsf/interfaces/cpu/stm32/eint/: STM32_EINT.c
  group vsf/interfaces/cpu/stm32/flash
    ../../../../../vsf/interfaces/cpu/stm32/flash/: STM32_FLASH.c
  group vsf/interfaces/cpu/stm32/gpio
    ../../../../../vsf/interfaces/cpu/stm32/gpio/: STM32_GPIO.c
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/CoreSupport
    ../../../../../vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x
    ../../../../../vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup
    ../../../../../vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/STM32_USB-FS-Device_Driver
    ../../../../../vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/STM32_USB-FS-Device_Driver/src/: usb_mem.c usb_regs.c
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/STM32F10x_StdPeriph_Driver
    ../../../../../vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c
  group vsf/interfaces/cpu/stm32/sdio
    ../../../../../vsf/interfaces/cpu/stm32/sdio/: STM32_SDIO.c
  group vsf/interfaces/cpu/stm32/spi
    ../../../../../vsf/interfaces/cpu/stm32/spi/: STM32_SPI.c
  group vsf/interfaces/cpu/stm32/timer
    ../../../../../vsf/interfaces/cpu/stm32/timer/: STM32_TIM.c
  group vsf/interfaces/cpu/stm32/usart
    ../../../../../vsf/interfaces/cpu/stm32/usart/: STM32_USART.c
  group vsf/interfaces/cpu/stm32/usbd
    ../../../../../vsf/interfaces/cpu/stm32/usbd/: STM32_USBD.c
  group vsf/stack/usb_device
    ../../../../../vsf/stack/usb_device/: vsf_usbd.c
  group vsf/stack/usb_device/CLASS/CDC
    ../../../../../vsf/stack/usb_device/class/CDC/: vsfusbd_CDC.c vsfusbd_CDCACM.c
  group vsf/stack/usb_device/CLASS/HID
    ../../../../../vsf/stack/usb_device/class/HID/: vsfusbd_HID.c
  group vsf/stack/usb_device/CLASS/MSC
    ../../../../../vsf/stack/usb_device/class/MSC/: SCSI.c vsfusbd_MSC_BOT.c
  group vsf/tool/buffer
    ../../../../../vsf/tool/buffer/: buffer.c
  group vsf/tool/fakefat32
    ../../../../../vsf/tool/fakefat32/: fakefat32.c
  group vsf/tool/list
    ../../../../../vsf/tool/list/: list.h
  group vsf/tool/vsfui_fb
    ../../../../../vsf/tool/vsfui_fb/: vsfui_fb.c
  group vsf_cfg
    ../vsf_cfg/: dal_cfg.h interfaces_cfg.h vsf_usbd_cfg.h
  group vsprog
    ../../../vsprog/: config.h vsprog.c
  group vsprog/driver/comport
    ../../../vsprog/driver/comport/: comport.c
  group vsprog/target
    ../../../../../src/target/: target.c
    ../../../vsprog/target/: target_data.c target_readconf.c
  group vsprog/target/at89s5x
    ../../../../../src/target/at89s5x/: at89s5x.c
  group vsprog/target/at91sam3
    ../../../../../src/target/at91sam3/: at91sam3.c
  group vsprog/target/avr32
    ../../../../../src/target/avr32/: avr32.c
  group vsprog/target/avr8
    ../../../../../src/target/avr8/: avr8.c avr8_hvpp.c avr8_hvsp.c avr8_isp.c avr8_jtag.c
  group vsprog/target/avrxmega
    ../../../../../src/target/avrxmega/: avrxmega.c
  group vsprog/target/c8051f
    ../../../../../src/target/c8051f/: c8051f.c c8051f_c2.c c8051f_jtag.c
  group vsprog/target/cfi
    ../../../../../src/target/cfi/: cfi.c
  group vsprog/target/comisp
    ../../../../../src/target/comisp/: comisp.c lpcarmisp.c stm32isp.c
  group vsprog/target/core/arm_adi
    ../../../../../src/target/core/arm_adi/: adi_v5p1.c
  group vsprog/target/cortex-m
    ../../../../../src/target/cortex-m/: cm.c cm_at91sam3.c cm_common.c cm_kinetis.c cm_lm3s.c cm_lpc1000.c cm_nuc100.c cm_stm32_fl.c cm_stm32f1.c cm_stm32f2.c cm_stm32l1.c
  group vsprog/target/df25xx
    ../../../../../src/target/df25xx/: df25xx.c
  group vsprog/target/ee24cxx
    ../../../../../src/target/ee24cxx/: ee24cxx.c
  group vsprog/target/ee93cx6
    ../../../../../src/target/ee93cx6/: ee93cx6.c
  group vsprog/target/hcs08
    ../../../../../src/target/hcs08/: hcs08.c
  group vsprog/target/hcs12
    ../../../../../src/target/hcs12/: hcs12.c
  group vsprog/target/kinetis
    ../../../../../src/target/kinetis/: kinetis.c
  group vsprog/target/lm3s
    ../../../../../src/target/lm3s/: lm3s.c
  group vsprog/target/lpc1000
    ../../../../../src/target/lpc1000/: lpc1000.c
  group vsprog/target/lpc900
    ../../../../../src/target/lpc900/: lpc900.c
  group vsprog/target/msp430
    ../../../../../src/target/msp430/: JTAGfunc.c msp430.c msp430_bsl.c msp430_jtagsbw.c
  group vsprog/target/nand
    ../../../../../src/target/nand/: nand.c
  group vsprog/target/nuc100
    ../../../../../src/target/nuc100/: nuc100.c
  group vsprog/target/psoc1
    ../../../../../src/target/psoc1/: psoc1.c
  group vsprog/target/sd
    ../../../../../src/target/sd/: sd.c
  group vsprog/target/sst32fhxx
    ../../../../../src/target/sst32hfxx/: sst32hfxx.c
  group vsprog/target/stm32f1
    ../../../../../src/target/stm32f1/: stm32f1.c
  group vsprog/target/stm32f2
    ../../../../../src/target/stm32f2/: stm32f2.c
  group vsprog/target/stm32l1
    ../../../../../src/target/stm32l1/: stm32l1.c
  group vsprog/target/stm8
    ../../../../../src/target/stm8/: stm8.c
  group vsprog/target/svf_player
    ../../../../../src/target/svf_player/: byte_tap.c svf_parser.c svf_player.c
  group vsprog/tools/memlist
    ../../../../../src/tools/memlist/: memlist.c
  group vsprog/tools/pgbar
    ../../../vsprog/tools/pgbar/: pgbar.c
  group vsprog/tools/strparser
    ../../../../../src/tools/strparser/: strparser.c
