# IAR project Versaloon.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xx8 ST STM32F10xx8
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\; ..\..\; ..\..\..\; ..\..\..\HW\Port\IAR\; ..\..\..\HW\Port\IAR\Delay\; ..\..\..\HW\; ..\..\..\HW\STM32F10x_Lib\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\HW\STM32F10x_Lib\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\HW\STM32F10x_Lib\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\HW\STM32F10x_Lib\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Tools\fifo\; ..\..\..\HW\VCOM\; ..\..\..\HW\Mass\; ..\..\..\Interfaces\JTAG\; ..\..\..\Interfaces\SWD\; ..\..\..\Interfaces\SWIM\; ..\..\..\Interfaces\SPI\; ..\..\..\Interfaces\PowerExt\; ..\..\..\Interfaces\IIC\; ..\..\..\Interfaces\C2\; ..\..\..\Interfaces\ISSP\; ..\..\..\Interfaces\LPC_ICP\; ..\..\..\Interfaces\MSP430_JTAG\; ..\..\..\Interfaces\BDM\; ..\..\..\USB_TO_XXX\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Versaloon_IAR.hex
  ILINK.IlinkOutputFile: Versaloon.out
  ILINK.IlinkIcfFile: Versaloon.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCOptStrategy: 0
  group (top)
    ../: app_cfg.h
    ../../../: main.c
  group HW
    ../../../HW/: HW.c stm32f10x_it.c
  group HW/Port/Delay
    ../../../HW/Port/IAR/Delay/: delay.c
  group HW/STM32F10x_Lib/Libraries/CMSIS/CM3/CoreSupport
    ../../../HW/STM32F10x_Lib/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group HW/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x
    ../../../HW/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group HW/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup
    ../../../HW/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s
  group HW/STM32F10x_Lib/Libraries/STM32_USB-FS-Device_Driver
    ../../../HW/STM32F10x_Lib/Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group HW/STM32F10x_Lib/Libraries/STM32F10x_StdPeriph_Driver
    ../../../HW/STM32F10x_Lib/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HW/USB/Mass
    ../../../HW/Mass/: mass_mal.c memory.c scsi_data.c usb_bot.c usb_scsi.c
  group HW/USB/ST_VCOM
    ../../../HW/VCOM/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group hw_cfg
    ../../: hw_cfg_MiniRC2.h hw_cfg_MiniRC3.h hw_cfg_MiniRC4.h hw_cfg_MiniRelease1.h hw_cfg_NanoRelease1.h hw_cfg_ProRC1.h
  group Interfaces/BDM
    ../../../Interfaces/BDM/: BDM.c
  group Interfaces/C2
    ../../../Interfaces/C2/: C2.c
  group Interfaces/IIC
    ../../../Interfaces/IIC/: IIC.c
  group Interfaces/ISSP
    ../../../Interfaces/ISSP/: ISSP.c
  group Interfaces/JTAG
    ../../../Interfaces/JTAG/: JTAG_TAP.c
  group Interfaces/LPC_ICP
    ../../../Interfaces/LPC_ICP/: LPC_ICP.c
  group Interfaces/MSP430_JTAG
    ../../../Interfaces/MSP430_JTAG/: MSP430_JTAG.c
  group Interfaces/PowerExt
    ../../../Interfaces/PowerExt/: PowerExt.c
  group Interfaces/SPI
    ../../../Interfaces/SPI/: SPI.c
  group Interfaces/SWD
    ../../../Interfaces/SWD/: SWD.c
  group Interfaces/SWIM
    ../../../Interfaces/SWIM/: SWIM.c
  group Tools/fifo
    ../../../Tools/fifo/: fifo.c
  group USB_TO_XXX
    ../../../USB_TO_XXX/: USB_TO_ADC.c USB_TO_BDM.C USB_TO_C2.c USB_TO_DAC.c USB_TO_GPIO.c USB_TO_IIC.c USB_TO_ISSP.c USB_TO_JTAG_HL.c USB_TO_JTAG_LL.c USB_TO_JTAG_RAW.c USB_TO_LPCICP.c USB_TO_MICROWIRE.c USB_TO_MSP430_JTAG.c USB_TO_POWER.c USB_TO_PWM.c USB_TO_SPI.c USB_TO_SWD.c USB_TO_SWIM.c USB_TO_USART.c USB_TO_XXX.c
