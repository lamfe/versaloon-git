# IAR project Versaloon.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xx8 ST STM32F10xx8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; _HARDWARE_VER=0x15; FLASH_LOAD_OFFSET=0x2000; __TARGET_CHIP__=stm32
  ICCARM.CCIncludePath2: ; ..\; ..\..\; ..\..\..\; ..\..\..\Tools\fifo\; ..\..\..\Interfaces\; ..\..\..\Interfaces\APP\; ..\..\..\USB_TO_XXX\; ..\..\..\..\..\vsf\; ..\..\..\..\..\vsf\interfaces\; ..\..\..\..\..\vsf\interfaces\cpu\stm32\; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\Port\IAR\; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\STM32F10x_Lib\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\STM32F10x_Lib\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\STM32F10x_Lib\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\STM32F10x_Lib\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Versaloon_IAR.hex
  ILINK.IlinkOutputFile: Versaloon.out
  ILINK.IlinkIcfFile: ..\..\Versaloon.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_MD; _HARDWARE_VER=0x15; __TARGET_CHIP__=stm32; FLASH_LOAD_OFFSET=0x2000
  ICCARM.CCOptLevel: 3
  group (top)
    ../: app_cfg.h
    ../../../: main.c
  group hw_cfg
    ../../: hw_cfg_MiniRelease1.h hw_cfg_NanoRelease1.h hw_cfg_STBee_Mini.h hw_cfg_stm32vl-discovery.h hw_cfg_stm8s-discovery.h
  group Interfaces
    ../../../Interfaces/: app_interfaces.c
  group Interfaces/APP/BDM
    ../../../Interfaces/APP/BDM/: BDM.c
  group Interfaces/APP/C2
    ../../../Interfaces/APP/C2/: C2.c
  group Interfaces/APP/DUSI
    ../../../Interfaces/APP/DUSI/: DUSI.c
  group Interfaces/APP/EBI
    ../../../Interfaces/APP/EBI/: EBI.c
  group Interfaces/APP/GPIO
    ../../../Interfaces/APP/GPIO/: GPIO.c
  group Interfaces/APP/IIC
    ../../../Interfaces/APP/IIC/: IIC.c
  group Interfaces/APP/ISSP
    ../../../Interfaces/APP/ISSP/: ISSP.c
  group Interfaces/APP/JTAG
    ../../../Interfaces/APP/JTAG/: JTAG_TAP.c
  group Interfaces/APP/LPC_ICP
    ../../../Interfaces/APP/LPC_ICP/: LPC_ICP.c
  group Interfaces/APP/MicroWire
    ../../../Interfaces/APP/MicroWire/: MicroWire.c
  group Interfaces/APP/MSP430_JTAG
    ../../../Interfaces/APP/MSP430_JTAG/: MSP430_JTAG.c
  group Interfaces/APP/PowerExt
    ../../../Interfaces/APP/PowerExt/: PowerExt.c
  group Interfaces/APP/PWM
    ../../../Interfaces/APP/PWM/: PWM.c
  group Interfaces/APP/SPI
    ../../../Interfaces/APP/SPI/: SPI.c
  group Interfaces/APP/SWD
    ../../../Interfaces/APP/SWD/: SWD.c
  group Interfaces/APP/SWIM
    ../../../Interfaces/APP/SWIM/: SWIM.c
  group Interfaces/APP/USART
    ../../../Interfaces/APP/USART/: USART.c
  group Tools/fifo
    ../../../Tools/fifo/: fifo.c
  group usb_protocol
    ../../../: usb_protocol_MSC.c usb_protocol_Versaloon.c
  group USB_TO_XXX
    ../../../USB_TO_XXX/: CommandProcessor.c USB_TO_ADC.c USB_TO_BDM.C USB_TO_C2.c USB_TO_DAC.c USB_TO_DUSI.c USB_TO_EBI.c USB_TO_GPIO.c USB_TO_IIC.c USB_TO_ISSP.c USB_TO_JTAG_HL.c USB_TO_JTAG_LL.c USB_TO_JTAG_RAW.c USB_TO_LPCICP.c USB_TO_MICROWIRE.c USB_TO_MSP430_JTAG.c USB_TO_POWER.c USB_TO_PWM.c USB_TO_SPI.c USB_TO_SWD.c USB_TO_SWIM.c USB_TO_USART.c USB_TO_XXX.c
  group vsf/dal
    ../../../../../vsf/dal/: dal.c
  group vsf/dal/df25xx
    ../../../../../vsf/dal/df25xx/: df25xx_drv.c
  group vsf/dal/df45xx
    ../../../../../vsf/dal/df45xx/: df45xx_drv.c
  group vsf/dal/ee24cxx
    ../../../../../vsf/dal/ee24cxx/: ee24cxx_drv.c
  group vsf/dal/ee93cx6
    ../../../../../vsf/dal/ee93cx6/: ee93cx6_drv.c
  group vsf/dal/mal
    ../../../../../vsf/dal/mal/: mal.c
  group vsf/dal/mic2826
    ../../../../../vsf/dal/mic2826/: mic2826_drv.c
  group vsf/dal/nrf24l01
    ../../../../../vsf/dal/nrf24l01/: nrf24l01_drv.c
  group vsf/dal/sd
    ../../../../../vsf/dal/sd/: sd_common.c sd_spi_drv.c
  group vsf/dal/usart_stream
    ../../../../../vsf/dal/usart_stream/: usart_stream.c
  group vsf/interfaces
    ../../../../../vsf/interfaces/: interfaces.c
  group vsf/interfaces/cpu/stm32
    ../../../../../vsf/interfaces/cpu/stm32/: core.c
  group vsf/interfaces/cpu/stm32/adc
    ../../../../../vsf/interfaces/cpu/stm32/adc/: STM32_ADC.c
  group vsf/interfaces/cpu/stm32/ebi
    ../../../../../vsf/interfaces/cpu/stm32/ebi/: STM32_EBI.c
  group vsf/interfaces/cpu/stm32/eint
    ../../../../../vsf/interfaces/cpu/stm32/eint/: STM32_EINT.c
  group vsf/interfaces/cpu/stm32/flash
    ../../../../../vsf/interfaces/cpu/stm32/flash/: STM32_FLASH.c
  group vsf/interfaces/cpu/stm32/gpio
    ../../../../../vsf/interfaces/cpu/stm32/gpio/: STM32_GPIO.c
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/CoreSupport
    ../../../../../vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x
    ../../../../../vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup
    ../../../../../vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/STM32_USB-FS-Device_Driver
    ../../../../../vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/STM32_USB-FS-Device_Driver/src/: usb_mem.c usb_regs.c
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/STM32F10x_StdPeriph_Driver
    ../../../../../vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c
  group vsf/interfaces/cpu/stm32/spi
    ../../../../../vsf/interfaces/cpu/stm32/spi/: STM32_SPI.c
  group vsf/interfaces/cpu/stm32/timer
    ../../../../../vsf/interfaces/cpu/stm32/timer/: STM32_TIM.c
  group vsf/interfaces/cpu/stm32/usart
    ../../../../../vsf/interfaces/cpu/stm32/usart/: STM32_USART.c
  group vsf/interfaces/cpu/stm32/usbd
    ../../../../../vsf/interfaces/cpu/stm32/usbd/: STM32_USBD.c
  group vsf/stack/usb_device
    ../../../../../vsf/stack/usb_device/: vsf_usbd.c
  group vsf/stack/usb_device/CLASS/CDC
    ../../../../../vsf/stack/usb_device/class/CDC/: vsfusbd_CDC.c
  group vsf/stack/usb_device/CLASS/HID
    ../../../../../vsf/stack/usb_device/class/HID/: vsfusbd_HID.c
  group vsf/stack/usb_device/CLASS/MSC
    ../../../../../vsf/stack/usb_device/class/MSC/: SCSI.c vsfusbd_MSC_BOT.c
  group vsf/tool/buffer
    ../../../../../vsf/tool/buffer/: buffer.c
  group vsf/tool/list
    ../../../../../vsf/tool/list/: list.h
