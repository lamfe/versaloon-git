# IAR project Versaloon.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xx8 ST STM32F10xx8
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\; ..\..\; ..\..\..\; ..\..\..\HW\Port\IAR\; ..\..\..\HW\Port\IAR\Delay\; ..\..\..\HW\; ..\..\..\HW\lib\CMSIS\Core\CM3\; ..\..\..\HW\lib\inc\; ..\..\..\Tools\fifo\; ..\..\..\HW\VCOM\; ..\..\..\HW\Mass\; ..\..\..\Interfaces\JTAG\; ..\..\..\Interfaces\SWJ\; ..\..\..\Interfaces\SWIM\; ..\..\..\Interfaces\SPI\; ..\..\..\Interfaces\PowerExt\; ..\..\..\Interfaces\I2C\; ..\..\..\Interfaces\C2\; ..\..\..\Interfaces\ISSP\; ..\..\..\Interfaces\LPC_ICP\; ..\..\..\Interfaces\MSP430_JTAG\; ..\..\..\VSLLink\; ..\..\..\USB_TO_XXX\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Versaloon_IAR.hex
  ILINK.IlinkOutputFile: Versaloon.out
  ILINK.IlinkIcfFile: Versaloon.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_MD
  group (top)
    ../: app_cfg.h
    ../../../: main.c
  group HW
    ../../../HW/: HW.c stm32f10x_it.c
  group HW/Lib
    ../../../HW/lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group HW/Lib/CMSIS
    ../../../HW/lib/CMSIS/Core/CM3/: core_cm3.c
  group HW/Lib/CMSIS/startup
    ../../../HW/lib/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s
  group HW/Port/Delay
    ../../../HW/Port/IAR/Delay/: delay.c
  group HW/USB/Mass
    ../../../HW/Mass/: mass_mal.c memory.c scsi_data.c usb_bot.c usb_scsi.c
  group HW/USB/ST_VCOM
    ../../../HW/VCOM/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group hw_cfg
    ../../: hw_cfg_MiniRC2.h hw_cfg_MiniRC3.h hw_cfg_MiniRC4.h hw_cfg_MiniRelease1.h hw_cfg_NanoRC1.h hw_cfg_ProRC1.h
  group Interfaces/C2
    ../../../Interfaces/C2/: C2.c
  group Interfaces/I2C
    ../../../Interfaces/I2C/: I2C.c
  group Interfaces/ISSP
    ../../../Interfaces/ISSP/: ISSP.c
  group Interfaces/JTAG
    ../../../Interfaces/JTAG/: JTAG_TAP.c
  group Interfaces/LPC_ICP
    ../../../Interfaces/LPC_ICP/: LPC_ICP.c
  group Interfaces/MSP430_JTAG
    ../../../Interfaces/MSP430_JTAG/: MSP430_JTAG.c
  group Interfaces/PowerExt
    ../../../Interfaces/PowerExt/: PowerExt.c
  group Interfaces/SPI
    ../../../Interfaces/SPI/: SPI.c
  group Interfaces/SWIM
    ../../../Interfaces/SWIM/: SWIM.c
  group Interfaces/SWJ
    ../../../Interfaces/SWJ/: SWJ.c
  group Tools/fifo
    ../../../Tools/fifo/: fifo.c
  group USB_TO_XXX
    ../../../USB_TO_XXX/: USB_TO_ADC.c USB_TO_C2.c USB_TO_DAC.c USB_TO_GPIO.c USB_TO_I2C.c USB_TO_ISSP.c USB_TO_JTAG_HL.c USB_TO_JTAG_LL.c USB_TO_LPCICP.c USB_TO_MICROWIRE.c USB_TO_MSP430_JTAG.c USB_TO_POWER.c USB_TO_PWM.c USB_TO_SPI.c USB_TO_SWIM.c USB_TO_SWJ.c USB_TO_USART.c USB_TO_XXX.c
  group VSLLink
    ../../../VSLLink/: VSLLink.c
