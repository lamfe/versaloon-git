# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; __TARGET_CHIP__=stm32; FLASH_LOAD_OFFSET=0x0000; CORE_DEBUG=STM32_DBG_SWD
  ICCARM.CCIncludePath2: ; ..\..\..\..\..\dongle\firmware\Projects\VSFCore\stm32\vsf_cfg\; ..\..\..\..\..\dongle\firmware\Projects\VSFCore\stm32\; ..\..\..\..\..\dongle\firmware\Projects\VSFCore\stm32\Interfaces\; ..\..\..\..\..\dongle\firmware\Projects\VSFCore\stm32\Interfaces\APP\; ..\..\..\..\..\vsf\; ..\..\..\..\..\vsf\interfaces\; ..\..\..\..\..\vsf\interfaces\cpu\stm32\; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\Port\IAR\; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\STM32F10x_Lib\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\STM32F10x_Lib\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\STM32F10x_Lib\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\STM32F10x_Lib\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\..\vsf\example
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.hex
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: VSFCore_STM32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_HD; __TARGET_CHIP__=stm32; FLASH_LOAD_OFFSET=0x0000; CORE_DEBUG=STM32_DBG_SWD
  ICCARM.CCIncludePath2: ; ..\..\..\..\..\dongle\firmware\Projects\VSFCore\stm32\vsf_cfg\; ..\..\..\..\..\dongle\firmware\Projects\VSFCore\stm32\; ..\..\..\..\..\dongle\firmware\Projects\VSFCore\stm32\Interfaces\; ..\..\..\..\..\dongle\firmware\Projects\VSFCore\stm32\Interfaces\APP\; ..\..\..\..\..\vsf\; ..\..\..\..\..\vsf\interfaces\; ..\..\..\..\..\vsf\interfaces\cpu\stm32\; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\Port\IAR\; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\STM32F10x_Lib\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\STM32F10x_Lib\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\STM32F10x_Lib\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\STM32F10x_Lib\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\..\src\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ../../: main.c
  group Interfaces
    ../../../../../dongle/firmware/Projects/VSFCore/stm32/Interfaces/: app_interfaces.c
  group Interfaces/APP/ADC
    ../../../../../dongle/firmware/Projects/VSFCore/stm32/Interfaces/APP/ADC/: ADC.c
  group Interfaces/APP/EBI
    ../../../../../dongle/firmware/Projects/VSFCore/stm32/Interfaces/APP/EBI/: EBI.c
  group Interfaces/APP/GPIO
    ../../../../../dongle/firmware/Projects/VSFCore/stm32/Interfaces/APP/GPIO/: GPIO.c
  group Interfaces/APP/IIC
    ../../../../../dongle/firmware/Projects/VSFCore/stm32/Interfaces/APP/IIC/: IIC.c
  group Interfaces/APP/SDIO
    ../../../../../dongle/firmware/Projects/VSFCore/stm32/Interfaces/APP/SDIO/: SDIO.c
  group Interfaces/APP/SPI
    ../../../../../dongle/firmware/Projects/VSFCore/stm32/Interfaces/APP/SPI/: SPI.c
  group Interfaces/APP/USART
    ../../../../../dongle/firmware/Projects/VSFCore/stm32/Interfaces/APP/USART/: USART.c
  group vsf/dal
    ../../../../dal/: dal.c
  group vsf/dal/cfi
    ../../../../dal/cfi/: cfi_drv.c
  group vsf/dal/df25xx
    ../../../../dal/df25xx/: df25xx_drv.c
  group vsf/dal/df45xx
    ../../../../dal/df45xx/: df45xx_drv.c
  group vsf/dal/ee24cxx
    ../../../../dal/ee24cxx/: ee24cxx_drv.c
  group vsf/dal/ee93cx6
    ../../../../dal/ee93cx6/: ee93cx6_drv.c
  group vsf/dal/mal
    ../../../../dal/mal/: mal.c
  group vsf/dal/mic2826
    ../../../../dal/mic2826/: mic2826_drv.c
  group vsf/dal/nand
    ../../../../dal/nand/: nand_drv.c
  group vsf/dal/nrf24l01
    ../../../../dal/nrf24l01/: nrf24l01_drv.c
  group vsf/dal/sd
    ../../../../dal/sd/: sd_common.c sd_sdio_drv.c sd_spi_drv.c
  group vsf/dal/stream
    ../../../../dal/stream/: stream.c
  group vsf/dal/usart_stream
    ../../../../dal/usart_stream/: usart_stream.c
  group vsf/interfaces
    ../../../../interfaces/: interfaces.c
  group vsf/interfaces/cpu/stm32
    ../../../../interfaces/cpu/stm32/: core.c
  group vsf/interfaces/cpu/stm32/adc
    ../../../../interfaces/cpu/stm32/adc/: STM32_ADC.c
  group vsf/interfaces/cpu/stm32/ebi
    ../../../../interfaces/cpu/stm32/ebi/: STM32_EBI.c
  group vsf/interfaces/cpu/stm32/eint
    ../../../../interfaces/cpu/stm32/eint/: STM32_EINT.c
  group vsf/interfaces/cpu/stm32/flash
    ../../../../interfaces/cpu/stm32/flash/: STM32_FLASH.c
  group vsf/interfaces/cpu/stm32/gpio
    ../../../../interfaces/cpu/stm32/gpio/: STM32_GPIO.c
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/CoreSupport
    ../../../../interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x
    ../../../../interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup
    ../../../../interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/STM32_USB-FS-Device_Driver
    ../../../../interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/STM32_USB-FS-Device_Driver/src/: usb_mem.c usb_regs.c
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/STM32F10x_StdPeriph_Driver
    ../../../../interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c
  group vsf/interfaces/cpu/stm32/sdio
    ../../../../interfaces/cpu/stm32/sdio/: STM32_SDIO.c
  group vsf/interfaces/cpu/stm32/spi
    ../../../../interfaces/cpu/stm32/spi/: STM32_SPI.c
  group vsf/interfaces/cpu/stm32/timer
    ../../../../interfaces/cpu/stm32/timer/: STM32_TIM.c
  group vsf/interfaces/cpu/stm32/usart
    ../../../../interfaces/cpu/stm32/usart/: STM32_USART.c
  group vsf/interfaces/cpu/stm32/usbd
    ../../../../interfaces/cpu/stm32/usbd/: STM32_USBD.c
  group vsf/stack/usb_device
    ../../../../stack/usb_device/: vsf_usbd.c
  group vsf/stack/usb_device/CLASS/CDC
    ../../../../stack/usb_device/class/CDC/: vsfusbd_CDCACM.c
  group vsf/stack/usb_device/CLASS/HID
    ../../../../stack/usb_device/class/HID/: vsfusbd_HID.c
  group vsf/stack/usb_device/CLASS/MSC
    ../../../../stack/usb_device/class/MSC/: SCSI.c vsfusbd_MSC_BOT.c
  group vsf/tool/buffer
    ../../../../tool/buffer/: buffer.c
  group vsf/tool/list
    ../../../../tool/list/: list.h
  group vsf_cfg
    ../../../vsf_cfg/: dal_cfg.h interfaces_cfg.h vsf_usbd_cfg.h
